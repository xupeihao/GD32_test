# Keil uVision project GD32F407RTE.uvprojx, settings and files
target Target_1 (6230000::V6.23::ARMCLANG)
  device: GD32F407VE GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.3.0
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: GD32F407RTE +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: HXTAL_VALUE=8000000,GD32F407
  c include: ..\User;..\Libraries;..\App;..\Hardware;..\FreeRTOS\include;..\FreeRTOS\portable\GCC\ARM_CM4F;..\FreeRTOS;..\FreeRTOS\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group App
    ../App/: App.h App.c
  group User
    ../User/: gd32f4xx_it.c main.c systick.c
  group LIBs
    ../Libraries/: lib_peripheral.c
    ../Libraries/adc/: adc_config.h
    ../Libraries/exti/: exti_config.h
    ../Libraries/i2c/: i2c_config.h
    ../Libraries/rtc/: rtc_config.h
    ../Libraries/spi/: spi_config.h
    ../Libraries/timer/: timer_config.h
    ../Libraries/usart/: usart_config.h
    ../Libraries/wdog/: wdog_config.h
  group LIBs/timer
    ../Libraries/timer/: lib_timer.c lib_timer5.c
  group LIBs/usart
    ../Libraries/usart/: lib_usart.c lib_usart0.c
  group BSP
    ../Hardware/: board_config.h bsp.h
  group FreeRTOS_Core
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c stream_buffer.c
  group FreeRTOS_Port
    ../FreeRTOS/portable/MemMang/: heap_4.c
    ../FreeRTOS/portable/GCC/ARM_CM4F/: port.c
software components: CMSIS:CORE 5.6.0, Device:Libopt 3.3.0, Device:Startup 3.3.0, Device:StdPeripherals:ADC 3.3.0, Device:StdPeripherals:DMA 3.3.0, Device:StdPeripherals:EXTI 3.3.0, Device:StdPeripherals:GPIO 3.3.0, Device:StdPeripherals:I2C 3.3.0, Device:StdPeripherals:MISC 3.3.0, Device:StdPeripherals:PMU 3.3.0, Device:StdPeripherals:RCU 3.3.0, Device:StdPeripherals:RTC 3.3.0, Device:StdPeripherals:SPI_I2S 3.3.0, Device:StdPeripherals:SYSCFG 3.3.0, Device:StdPeripherals:TIMER 3.3.0, Device:StdPeripherals:USART 3.3.0
